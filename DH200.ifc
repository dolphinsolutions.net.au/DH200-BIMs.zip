Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-07-01T15:21:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 01 15:21:49 2024 * Host: Administrator * Database: C:\Users\Lenovo\AppData\Local\Temp\{7E58D0EF-3712-482C-8C64-032AA768C8C6}\ifc * Database version: 5507 * Database creation date: Mon Jul 01 15:21:48 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 01 15:21:49 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 01 15:21:49 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcDoor: DH200, DH200:DH200:205129
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Satin_suffix_.5PowderCoated_.6CeramicCoated
OverallHeight: 52 mm; OverallWidth: 71 mm
Pset_DoorCommon - Reference: DH200; IsExternal: no
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DoorLeverHandleSet
